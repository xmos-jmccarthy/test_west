## west.yml
```yaml
manifest:
  defaults:
    remote: upstream
    
  remotes:
    - name: upstream
      url-base: github.com/xmos-jmccarthy
      
  self:
      path: test_west
```
